# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Project +hex
  AfterMake: fromelf --bin !L --output .\build\Project.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\Application;..\usr-drivers\gpio;..\usr-drivers\usart;..\usr-drivers\usart\config;..\modules\init_module;..\modules\ring;..\modules\main_hook;..\modules\usr_device;..\modules\runtime;..\modules\rtu_master;..\modules\console;..\modules\at\include;..\modules\wifi;..\modules\key;..\modules\led;..\modules\oled;..\packages\agile_modbus\inc;..\packages\agile_led\inc;..\packages\agile_button\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group usr-drivers
    ../usr-drivers/gpio/: drv_gpio.c
    ../usr-drivers/usart/config/: drv_usart_config.c
    ../usr-drivers/usart/: drv_usart.c
    ../usr-drivers/wdt/: drv_wdt.c
  group modules
    ../modules/ring/: ringbuffer.c ringblk_buf.c
    ../modules/init_module/: init_module.c
    ../modules/console/: console.c
    ../modules/main_hook/: main_hook.c
    ../modules/runtime/: runtime.c
    ../modules/rtu_master/: rtu_master.c
    ../modules/at/src/: at_cli.c at_client.c at_utils.c
    ../modules/wifi/: wifi.c wifi_tcp_slave.c
    ../modules/key/: key.c
    ../modules/led/: led.c
    ../modules/usr_device/: usr_device.c
    ../modules/oled/: oled.c
  group agile_modbus
    ../packages/agile_modbus/src/: agile_modbus.c agile_modbus_rtu.c agile_modbus_tcp.c
  group agile_led
    ../packages/agile_led/src/: agile_led.c
  group agile_button
    ../packages/agile_button/src/: agile_button.c
software components: CMSIS:CORE 5.4.0, RTOS:kernel 3.1.3, RTOS:shell 3.1.3
